start:
	cls
	ncr
	ldi 0x00
  	tab
  	ldi 0x00
  	pos
  	ldi 0x00
  	tab
print:
	lda text
	cmp 0x00
	jmp print_1_start
	dly 0x01
	out
	inc
	lpc print
print_1_start:
	ldi 0x01
  	tab
  	ldi 0x00
  	pos
  	ldi 0x00
  	tab
	jmp print_1
print_1:
	lda text_1
	cmp 0x00
	jmp loop
	dly 0x01
	out
	inc
	lpc print_1
input:
	byte 0x30
text:
	byte 0x54
	byte 0x75
	byte 0x67
	byte 0x6d
	byte 0x61
	byte 0x3a
	byte 0x20
	byte 0x20
	byte 0x20
	byte 0x20
	byte 0x20
	byte 0x20
	byte 0x20
	byte 0x20
	byte 0x20
text_1:
	byte 0x41
	byte 0x53
	byte 0x43
	byte 0x49
	byte 0x49
	byte 0x3a
	byte 0x20
	byte 0x20
	byte 0x20
	byte 0x20
	byte 0x20
	byte 0x20
	byte 0x20
	byte 0x20
loop:
	ldi 0x00
	tab
	ldi 0x0f
	pos
	ldi 0x00
	in
	cmp 0x52
	jmp exit
	cmp 0x4d
	jmp exit
	cmp 0x4b
	jmp exit
	cmp 0x6c
	jmp exit
	sta input
	ldi 0x00
	tab
	lda input
	out
	ldi 0x01
	tab
	ldi 0x0e
	pos
	num input
	lpc loop
exit:
	cls
	byte 0x00